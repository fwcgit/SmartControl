# Keil uVision project SmartControl.uvproj, settings and files
target smartControl (MCS-51)
  device: STC15W4K32S4 STC
  cpu: IRAM(0-0xFF) XRAM(0-0xEFF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: SmartControl +hex
  c flags: Optimize=8 SizeSpeed=1
  group main
    ./: STARTUP.A51 main.c
  group config
    ./: config.c config.h
  group utils
    ./: utils.h utils.c
  group uart
    ./: Uart.h Uart1.c Uart2.c Uart3.c UartData.c
  group control
    ./: device.c device.h
  group adc
    ./: adc.c adc.h
  group sensor
    ./: DHT.c DHT.h DS18B20.c DS18B20.h
  group pwm
    ./: pwm.c pwm.h
